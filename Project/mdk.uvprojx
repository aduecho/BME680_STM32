# Keil uVision project mdk.uvprojx, settings and files
target BME680 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mdk +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\FWLib;..\User;..\StartUp;..\FWLib\STM32F10x_StdPeriph_Driver\inc;..\BME\algo;..\BME\API;..\BME\App;..\usb_virture_com;..\STM32_USB-FS-Device_Driver\inc;..\BME\Config;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FwLib
    ../FWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group StartUp
    ../StartUp/: startup_stm32f10x_md.s
  group User
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../User/: stm32f10x_it.c main.c sw_delay.c SysTick.c
  group BME
    ../BME/App/: bsec_integration.c
    ../BME/API/: bme680.c
    ../BME/algo/: libalgobsec.lib
  group STM32_USB-FS-Device_Driver
    ../STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group VCP
    ../usb_virture_com/: usb_desc.c usb_endp.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c
  group BME_Config
    ../BME/Config/: bsec_serialized_configurations_iaq.c
software components: CMSIS:CORE 5.1.1
